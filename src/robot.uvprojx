# Keil uVision project robot.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: robot
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: Delay.c Delay.h EnableGPIOx.c EnableGPIOx.h HexToString.c HexToString.h IntToString.c IntToString.h LCD_Config.c LCD_Config.h main.c SystemClock.c SystemClock.h UARTConfig.c UARTConfig.h PWM_Config.c PWM_Config.h Robot.h Robot.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
